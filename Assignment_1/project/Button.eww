<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Button.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\test\project\test.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Downloads\uart\uart\project\uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
