# IAR project Ass3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE16Z64xxx4 NXP MKE16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKE16Z64VLF4; FRDM_KE16Z; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: ..\source; ..\CMSIS\Include; ..\source\HAL\HAL_CLOCK; ..\source\HAL\HAL_CORE_M0+; ..\source\HAL\HAL_GPIO; ..\source\HAL\HAL_PORT; ..\source\Driver\Driver_Button; ..\source\Driver\Driver_Led; ..\source\HAL\HAL_FTM; ..\source\HAL\HAL_SYSTICK; ..\MKE16Z4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ass3.srec
  ILINK.IlinkOutputFile: Ass3.out
  ILINK.IlinkIcfFile: C:\Users\THANG\Desktop\Linker\MKE16Z64xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h core_cm7.h mpu_armv7.h
  group Source/Application
    ../source/App/: Application.c Application.h
  group Source/Driver/Driver_Button
    ../source/Driver/Driver_Button/: Driver_Button.c Driver_Button.h
  group Source/Driver/Driver_Led
    ../source/Driver/Driver_Led/: Driver_Led.c Driver_Led.h
  group Source/HAL/HAL_CLOCK
    ../source/HAL/HAL_CLOCK/: HAL_CLOCK.c HAL_CLOCK.h
  group Source/HAL/HAL_CORE_M0+
    ../source/HAL/HAL_CORE_M0+/: HAL_CORE_M0+.c HAL_CORE_M0+.h
  group Source/HAL/HAL_FTM
    ../source/HAL/HAL_FTM/: HAL_FTM.c HAL_FTM.h
  group Source/HAL/HAL_GPIO
    ../source/HAL/HAL_GPIO/: HAL_GPIO.c HAL_GPIO.h
  group Source/HAL/HAL_PORT
    ../source/HAL/HAL_PORT/: HAL_PORT.c HAL_PORT.h
  group Source/HAL/HAL_SYSTICK
    ../source/HAL/HAL_SYSTICK/: HAL_SYSTICK.c HAL_SYSTICK.h
  group Startup
    ../MKE16Z4/: startup_MKE16Z4.s system_MKE16Z4.c system_MKE16Z4.h
