# IAR project ass4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE16Z64xxx4 NXP MKE16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKE16Z64VLF4
  ICCARM.CCIncludePath2: ..\source; ..\source\App; ..\source\Driver; ..\source\Driver\Driver_Button; ..\source\Driver\Driver_Led; ..\source\Driver\Driver_lpit; ..\source\HAL\HAL_CLOCK; ..\source\HAL\HAL_GPIO; ..\source\HAL\HAL_PORT; ..\source\HAL\HAL_LPIT; ..\MKE16Z4; ..\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ass4.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source/APP
    ../source/App/: Application.c Application.h
  group source/DRIVER/DRIVER_LED
    ../source/Driver/Driver_Led/: Driver_Led.c Driver_Led.h
  group source/DRIVER/DRIVER_LPIT
    ../source/Driver/Driver_lpit/: Driver_LPIT.c Driver_LPIT.h
  group source/HAL/HAL_CLOCK
    ../source/HAL/HAL_CLOCK/: HAL_CLOCK.c HAL_CLOCK.h
  group source/HAL/HAL_GPIO
    ../source/HAL/HAL_GPIO/: HAL_GPIO.c HAL_GPIO.h
  group source/HAL/HAL_PORT
    ../source/HAL/HAL_PORT/: HAL_PORT.c HAL_PORT.h
  group source/HAL/HAL_LPIT
    ../source/HAL/HAL_LPIT/: HAL_LPIT.c HAL_LPIT.h
  group startup
    ../MKE16Z4/: startup_MKE16Z4.s system_MKE16Z4.c system_MKE16Z4.h
