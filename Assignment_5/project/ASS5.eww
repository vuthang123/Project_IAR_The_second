<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\Assignment_4\project\ass4.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\uart.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Downloads\uart\uart\project\uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
